# IAR project contiki-stm32.ewp, settings and files
configuration hello-world (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; AUTOSTART_ENABLE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\; ..\..\..\apps\shell; ..\..\..\core; ..\..\..\core\sys; ..\..\..\lib; ..\..\..\cpu\arm\stm32f103; ..\..\..\cpu\arm\stm32f103\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\cpu\arm\stm32f103\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\cpu\arm\stm32f103\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\platform\stm32dk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: contiki-stm32.bin
  ILINK.IlinkOutputFile: contiki-stm32.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration timer-test (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; AUTOSTART_ENABLE
  ICCARM.CCIncludePath2: ..\..\..\core; ..\..\..\core\sys; ..\..\..\lib; ..\..\..\cpu\arm\stm32f10x; ..\..\..\cpu\arm\stm32f10x\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\cpu\arm\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\cpu\arm\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\platform\stm32dk
  OBJCOPY.OOCOutputFile: contiki-stm32.srec
configuration process-post-test (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103V8 ST STM32F103V8
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: contiki-stm32.srec
configuration process-post-isr-test (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103V8 ST STM32F103V8
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: contiki-stm32.srec
  group apps/serial-shell
    ../../../apps/serial-shell/: serial-shell.c serial-shell.h
  group apps/shell
    ../../../apps/shell/: shell-base64.h shell-blink.c shell-blink.h shell-coffee.h shell-collect-view.h shell-download.h shell-exec.h shell-file.h shell-httpd.h shell-irc.h shell-memdebug.h shell-netperf.h shell-netstat.c shell-netstat.h shell-ping.c shell-ping.h shell-power.h shell-powertrace.h shell-ps.c shell-ps.h shell-reboot.c shell-reboot.h shell-rime-debug-runicast.h shell-rime-debug.h shell-rime-neighbors.h shell-rime-netcmd.h shell-rime-ping.h shell-rime-sendcmd.h shell-rime-sniff.h shell-rime-unicast.h shell-rime.h shell-rsh.h shell-run.h shell-sendtest.h shell-sky.h shell-tcpsend.h shell-text.c shell-text.h shell-time.c shell-time.h shell-udpsend.h shell-vars.c shell-vars.h shell-wget.h shell.c shell.h
  group core/dev
    ../../../core/dev/: leds.c leds.h radio.h serial-line.c serial-line.h spi.h
  group core/lib
    ../../../core/lib/: aes-128.c aes-128.h assert.c assert.h crc16.c crc16.h gcr.c gcr.h ifft.c ifft.h list.c list.h me.c me.h me_tabs.c me_tabs.h memb.c memb.h mmem.c mmem.h petsciiconv.c petsciiconv.h print-stats.c print-stats.h random.c random.h ringbuf.c ringbuf.h sensors.c sensors.h settings.c settings.h trickle-timer.c trickle-timer.h
  group core/net
    ../../../core/net/: link-stats.c link-stats.h linkaddr.c linkaddr.h nbr-table.c nbr-table.h net-debug.c net-debug.h netstack.c netstack.h packetbuf.c packetbuf.h queuebuf.c queuebuf.h
  group core/net/ip
    ../../../core/net/ip/: dhcpc.c dhcpc.h ip64-addr.c ip64-addr.h psock.c psock.h resolv.c resolv.h simple-udp.c simple-udp.h slipdev.c slipdev.h tcp-socket.c tcp-socket.h tcpip.c tcpip.h udp-socket.c udp-socket.h uip-debug.c uip-debug.h uip-nameserver.c uip-nameserver.h uip-packetqueue.c uip-packetqueue.h uip-split.c uip-split.h uip-udp-packet.c uip-udp-packet.h uip.h uip_arch.h uiplib.c uiplib.h uipopt.h
  group core/net/ipv4
    ../../../core/net/ipv4/: uaodv-def.h uaodv-rt.c uaodv-rt.h uaodv.c uaodv.h uip-fw-drv.c uip-fw-drv.h uip-fw.c uip-fw.h uip-neighbor.c uip-neighbor.h uip-over-mesh.c uip-over-mesh.h uip.c uip_arp.c uip_arp.h
  group core/net/rpl
    ../../../core/net/rpl/: rpl-conf.h rpl-dag-root.c rpl-dag-root.h rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-ns.h rpl-of0.c rpl-private.h rpl-timers.c rpl.c rpl.h
  group core/sys
    ../../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group cpu/arm/stm32f103
    ../../../cpu/arm/stm32f103/: clock.c rtimer-arch.c stm32f10x_it.c uart-debug.c
  group cpu/arm/stm32f103/Libraries/CMSIS
    ../../../cpu/arm/stm32f103/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../cpu/arm/stm32f103/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group cpu/arm/stm32f103/Libraries/EWARM
    ../../../cpu/arm/stm32f103/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group cpu/arm/stm32f103/Libraries/StdPeriph_Driver
    ../../../cpu/arm/stm32f103/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group dev
    ../../../dev/cc2520/: cc2520.c cc2520.h cc2520_const.h
  group example/hello-world
    ../hello-world/: hello-world.c
  group example/process-post-isr-test
    ../process-post-isr/: process-post-isr-test.c
  group example/process-post-test
    ../process-post/: process-post-test.c
  group example/timer-test
    ../timer-test/: timer-test.c
  group platform/stm32dk
    ../../../platform/stm32dk/: contiki-conf.h contiki-main.c platform-conf.h
